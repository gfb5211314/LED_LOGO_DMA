# Keil uVision project LED_LOGO_DMA.uvprojx, settings and files
target LED_LOGO_DMA (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED_LOGO_DMA +hex
  AfterMake: fromelf --bin --output .\LED_LOGO_DEBUG\LED_LOGO_DMA.BIN    .\LED_LOGO_DEBUG\LED_LOGO_DMA.AXF
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,ARM_MATH_CM3
  c misc: --C99
  c include: ../Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc;        ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;        ../Drivers/CMSIS/Include;        ..\BSP;        ..\App;   ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;   ../Middlewares/Third_Party/FreeRTOS/Source/include;   ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c freertos.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_adc.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c
  group DSP_lib
    ../Drivers/CMSIS/DSP_Lib/Source/TransformFunctions/: arm_cfft_f32.c
  group Bsp
    ../BSP/: bsp_led.c bsp_tim.c bsp_fft.c bsp_gpio.c bsp_ws2812.c bsp_dma.c bsp_adc.c bsp_usart.c stm_flash.c crc.c bsp_update.c bsp_esp32.c bsp_nrf24l01.c bsp_commun.c bsp_e61.c
  group App
    ../App/: ws2812_app.c esp32_app.c at_nrf24l01_app.c fft_app.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c tasks.c croutine.c event_groups.c list.c queue.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
